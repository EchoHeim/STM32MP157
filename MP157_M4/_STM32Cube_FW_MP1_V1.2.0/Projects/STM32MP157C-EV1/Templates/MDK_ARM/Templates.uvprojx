# Keil uVision project Templates.uvprojx, settings and files
target Engineering (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.0.0.1-dev5
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Templates
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32MP157Cxx,CORE_CM4
  c include: ../Inc;../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ./: startup_stm32mp15xx.s
  group Application/User
    ../Src/: lock_resource.c main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c
  group Doc
    ../: readme.txt
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
target Production (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.0.0.1-dev5
  cpu: as above
  output: Templates
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32MP157Cxx,CORE_CM4
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\stm32mp15xx_m4.sct
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
