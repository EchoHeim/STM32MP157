# Keil uVision project ADC_SingleConversion_TriggerTimer_DMA.uvprojx, settings and files
target ADC_SingleConversion_TriggerTimer_DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157CAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.1.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: ADC_SingleConversion_TriggerTimer_DMA +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Cxx
  c include: ../Inc;../../../../../../Drivers/BSP/STM32MP15xx_DISCO;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc;../../../../../../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ../: readme.txt
    ./: startup_stm32mp15xx.s
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c lock_resource.c stm32mp1xx_hal_msp.c stm32mp1xx_it.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32MP15xx_DISCO/: stm32mp15xx_disco.c stm32mp15xx_disco_stpmic1.c stm32mp15xx_disco_bus.c
  group Drivers/CMSIS
    ../Src/: system_stm32mp1xx.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../../../../../../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
