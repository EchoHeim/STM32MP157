# Keil uVision project Template.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32MP157DAAx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Dxx
  c include: ..\User;..\HAL\Inc;..\SYSTEM;..\CMSIS\Include;..\CMSIS\STM32MP1xx\Include;..\BSP\gpio;..\BSP\wwdg
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\SCRIPT\stm32mp15xx_m4.sct
  group StartUp
    ../CMSIS/STM32MP1xx/Source/arm/: startup_stm32mp15xx.s
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
  group HAL
    ../HAL/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_spi_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c stm32mp1xx_hal_usart.c stm32mp1xx_hal_usart_ex.c stm32mp1xx_hal_wwdg.c
  group BSP
    ../BSP/gpio/: gpio.c
    ../BSP/wwdg/: wwdg.c
  group User
    ./: main.c stm32mp1xx_it.c
    ../CMSIS/STM32MP1xx/Source/: system_stm32mp1xx.c
  group Readme
    ../: readme.txt
